.title KiCad schematic
.include "AirTemp.lib"
.include "CoolantTemp.lib"
.include "MPS V2.lib"
.include "Rheostat.lib"
.include "TPSV2.lib"
R828 Net-_Q805-Pad2_ Net-_Q700-Pad1_ 10K
R706 Net-_D701-Pad1_ 0 180K
R702 Net-_C700-Pad1_ 0 180K
R705 AUX7-12V Net-_Q701-Pad1_ 1K
R823 Net-_Q806-Pad2_ Net-_Q701-Pad1_ 10K
R712 AUX7-12V Net-_Q702-Pad1_ 1k
R824 Net-_Q806-Pad2_ Net-_Q702-Pad1_ 10k
Q701 Net-_Q701-Pad1_ Net-_D701-Pad1_ 0 BCY58-IX
R703 AUX7-12V Net-_Q700-Pad1_ 1K
Q700 Net-_Q700-Pad1_ Net-_C700-Pad1_ 0 BCY58-IX
R516 Net-_Q505-Pad2_ Int-3 5k1
R517 Net-_Q505-Pad2_ Net-_Q701-Pad1_ 3k9
R518 Net-_Q505-Pad2_ Int-1 3k9
R551 Net-_Q550-Pad2_ Net-_Q702-Pad1_ 3k9
R501 Net-_Q500-Pad2_ Net-_Q700-Pad1_ 3k9
R502 Net-_Q500-Pad2_ Int-3 5k1
R500 Net-_Q500-Pad2_ Int-1 3k9
R833 Net-_Q805-Pad2_ Net-_Q703-Pad1_ 10K
Q702 Net-_Q702-Pad1_ Net-_D702-Pad1_ 0 BCY58-IX
R714 AUX7-12V Net-_Q703-Pad1_ 1K
Q703 Net-_Q703-Pad1_ Net-_C701-Pad2_ 0 BCY58-IX
R715 Net-_C701-Pad2_ 0 180k
R711 Net-_D702-Pad1_ 0 180K
R830 AUX7-12V Net-_Q805-Pad1_ 2K
Q805 Net-_Q805-Pad1_ Net-_Q805-Pad2_ 0 BCY58-IX
R550 Net-_Q550-Pad2_ Int-2 3k9
R552 Net-_Q550-Pad2_ Int-3 5k1
R826 AUX7-12V Net-_Q806-Pad1_ 2K
Q806 Net-_Q806-Pad1_ Net-_Q806-Pad2_ 0 BCY58-IX
R832 Int-7 Net-_Q805-Pad1_ 5k1
R831 Int-7 Net-_Q806-Pad1_ 5k1
R566 Net-_Q555-Pad2_ Int-3 5k1
R567 Net-_Q555-Pad2_ Net-_Q703-Pad1_ 3k9
R568 Net-_Q555-Pad2_ Int-2 3k9
R563 Net-_Q553-Pad2_ Net-_Q554-Pad1_ 30
R559 Net-_D501-Pad1_ Net-_D550-Pad2_ 820
D550 Net-_D550-Pad2_ 0 DIODE.5V
Q555 Net-_Q554-Pad2_ Net-_Q555-Pad2_ 0 BCY58-IX
Q554 Net-_Q554-Pad1_ Net-_Q554-Pad2_ Net-_D550-Pad2_ BSX45
R564 E24-12V Net-_Q553-Pad2_ 27
R565 E24-12V Net-_Q554-Pad2_ 300
Q504 Net-_Q504-Pad1_ Net-_Q504-Pad2_ Int-4 BSX45
Q505 Net-_Q504-Pad2_ Net-_Q505-Pad2_ 0 BCY58-IX
R515 E24-12V Net-_Q504-Pad2_ 300
R503 E24-12V Net-_Q500-Pad1_ 300
Q501 Net-_Q501-Pad1_ Net-_Q500-Pad1_ Int-4 BSX45
Q500 Net-_Q500-Pad1_ Net-_Q500-Pad2_ 0 BCY58-IX
R553 E24-12V Net-_Q550-Pad1_ 300
Q550 Net-_Q550-Pad1_ Net-_Q550-Pad2_ 0 BCY58-IX
Q551 Net-_Q551-Pad1_ Net-_Q550-Pad1_ Net-_D550-Pad2_ BSX45
R556 E4-INJ4-8 Net-_C550-Pad1_ 6
R557 E4-INJ4-8 Net-_C550-Pad1_ 6
R560 Net-_C551-Pad2_ 0 6.8
C551 Net-_C551-Pad1_ Net-_C551-Pad2_ 6.8u
Q552 Net-_C550-Pad1_ Net-_Q552-Pad2_ Net-_D501-Pad1_ AUY21
Q553 Net-_C551-Pad1_ Net-_Q553-Pad2_ Net-_D501-Pad1_ AUY21
R562 E6-INJ7-2 Net-_C551-Pad1_ 6
R561 E6-INJ7-2 Net-_C551-Pad1_ 6
C550 Net-_C550-Pad1_ Net-_C550-Pad2_ 6.8u
R558 Net-_C550-Pad2_ 0 6.8
Q503 Net-_C501-Pad1_ Net-_Q503-Pad2_ Net-_D501-Pad1_ AUY21
Q502 Net-_C500-Pad1_ Net-_Q502-Pad2_ Net-_D501-Pad1_ AUY21
R509 Net-_D501-Pad1_ Int-4 820
R504 Net-_Q502-Pad2_ Net-_Q501-Pad1_ 30
R505 E24-12V Net-_Q502-Pad2_ 27
R513 Net-_Q503-Pad2_ Net-_Q504-Pad1_ 30
R514 E24-12V Net-_Q503-Pad2_ 27
D501 E24-12V Net-_D501-Pad1_ DIODE.5V
C500 Net-_C500-Pad1_ Net-_C500-Pad2_ 6.8u
R506 E3-INJ1-5 Net-_C500-Pad1_ 6
R507 E3-INJ1-5 Net-_C500-Pad1_ 6
R508 Net-_C500-Pad2_ 0 6.8
R555 E24-12V Net-_Q552-Pad2_ 27
R554 Net-_Q552-Pad2_ Net-_Q551-Pad1_ 30
D500 Int-4 0 DIODE.5V
R510 Net-_C501-Pad2_ 0 6.8
R511 E5-INJ6-3 Net-_C501-Pad1_ 6
C501 Net-_C501-Pad1_ Net-_C501-Pad2_ 6.8u
R512 E5-INJ6-3 Net-_C501-Pad1_ 6
D701 Net-_D701-Pad2_ Net-_D701-Pad1_ 1N904
R707 Net-_D701-Pad2_ E21-PG 3K
R704 Net-_C700-Pad2_ Net-_D701-Pad1_ 300
C700 Net-_C700-Pad1_ Net-_C700-Pad2_ 2.2n
R700 Net-_D700-Pad2_ E22-PG 3K
R708 Net-_Q700-Pad1_ E21-PG 3K
D700 Net-_D700-Pad2_ Net-_C700-Pad1_ 1N904
R701 Net-_Q701-Pad1_ E22-PG 3K
D703 Net-_D703-Pad2_ Net-_C701-Pad2_ 1N904
D702 Net-_D702-Pad2_ Net-_D702-Pad1_ 1N904
R709 E14-PG Net-_D702-Pad2_ 3K
R718 E13-PG Net-_D703-Pad2_ 3K
R713 Net-_D702-Pad1_ Net-_C701-Pad1_ 300
C701 Net-_C701-Pad1_ Net-_C701-Pad2_ 2.2n
R710 E14-PG Net-_Q703-Pad1_ 3K
R717 E13-PG Net-_Q702-Pad1_ 3K
R200 AUX6-VE^ E10-MPS 120K
R519 Int-1 AUX7-12V 1K
R570 Int-2 E2-TPS 5k1
R520 Int-1 E25-DIAG1 5k1
R205 AUX1-10V E10-MPS 680K
D201 Net-_D201-Pad2_ Net-_D201-Pad1_ 1N904
R202 E10-MPS Net-_D201-Pad2_ 820
D202 E10-MPS Net-_D201-Pad2_ 1N904
R229 Net-_R229-Pad1_ E10-MPS 18K
R204 0 Net-_D201-Pad1_ 2k2
R206 AUX1-10V E10-MPS 33K
R522 Net-_Q506-Pad2_ AUX18-BP 4k7
R523 Net-_Q506-Pad2_ AUX16-EP 3k6
R569 Int-2 AUX7-12V 1K
R571 Net-_Q556-Pad2_ AUX14-MP^ 3K
R573 Net-_Q556-Pad2_ AUX16-EP 3k6
Q506 Int-1 Net-_Q506-Pad2_ 0 BCY58-IX
Q556 Int-2 Net-_Q556-Pad2_ 0 BCY58-IX
R572 Net-_Q556-Pad2_ AUX15-BP 4k7
R521 Net-_Q506-Pad2_ AUX17-MP^ 3K
D611 AUX18-BP Net-_D611-Pad1_ 1N904
D612 AUX15-BP Net-_D611-Pad1_ 1N904
D613 Net-_D613-Pad2_ Net-_D611-Pad1_ ZENER_11.4
R628 Net-_D613-Pad2_ 0 10K
R629 Net-_D613-Pad2_ E18-START 1k3
R627 Net-_D611-Pad1_ Net-_C602-Pad1_ 24K
R625 Net-_C602-Pad1_ AUX7-12V 15K
R155 AUX1-10V E2-TPS 5k1
D119 Net-_D119-Pad2_ E2-TPS 1N904
R201 AUX6-VE^ E10-MPS 27K
R151 Net-_D119-Pad2_ E10-MPS 150K
R152 Net-_D119-Pad2_ E10-MPS 12K
D210 Net-_D210-Pad2_ AUX2-IDL 1N904
R405 Net-_Q401-Pad3_ 0 3
Q604 Net-_Q604-Pad1_ Net-_C602-Pad2_ Net-_Q604-Pad3_ S2672
C603 Net-_C602-Pad1_ Net-_C602-Pad2_ 2.2u
R228 Net-_Q203-Pad2_ Net-_D211-Pad2_ 47K
D211 Net-_D211-Pad2_ AUX2-IDL 1N904
R623 0 Net-_Q604-Pad3_ 130K
R620 Net-_D610-Pad2_ 0 10K
R622 0 Net-_C602-Pad2_ 510K
R230 Net-_R230-Pad1_ Net-_Q203-Pad1_ 6k2
XRV1 Net-_R230-Pad1_ Net-_R229-Pad1_ Net-_D210-Pad2_ RHEOSTAT_POS 0 rheostat
Q203 Net-_Q203-Pad1_ Net-_Q203-Pad2_ AUX1-10V S2066
R227 Net-_Q203-Pad2_ AUX1-10V 22K
D401 Net-_D401-Pad1_ Net-_D401-Pad2_ PMP_CNTL_ZENER
D403 Net-_D401-Pad1_ Int-4 1N904
D400 AUX13-SV Net-_C400-Pad1_ 1N904
C400 Net-_C400-Pad1_ 0 2.2u
R402 Net-_Q401-Pad3_ Net-_D401-Pad2_ 1K
R400 Net-_C400-Pad1_ 0 300K
R408 Net-_Q400-Pad2_ Net-_C400-Pad1_ 1K
R404 E18-START Net-_D401-Pad2_ 500
R403 Net-_Q401-Pad3_ Net-_D401-Pad1_ 1k2
Q401 E19-FPR Net-_D401-Pad1_ Net-_Q401-Pad3_ BSX45
R621 Net-_D610-Pad2_ E18-START 5k1
D610 Net-_D610-Pad2_ Net-_C602-Pad2_ ZENER_0.1
R407 Net-_D402-Pad2_ E19-FPR 68
D402 Net-_D402-Pad2_ AUX7-12V 1N904
Q400 AUX7-12V Net-_Q400-Pad2_ Net-_Q400-Pad3_ S2672
R401 Net-_Q400-Pad3_ Net-_D401-Pad1_ 470
C602 Net-_C602-Pad1_ Net-_C602-Pad2_ 2.2u
R624 Net-_Q604-Pad1_ AUX7-12V 510K
Q605 Net-_C602-Pad1_ Net-_Q604-Pad3_ 0 S2672
R836 0 Net-_R814-Pad2_ 36K
R815 Net-_R815-Pad1_ Net-_C803-Pad2_ 130K
C803 0 Net-_C803-Pad2_ 470n
Q804 AUX11-TGL Net-_Q804-Pad2_ 0 BCY58-IX
R829 Net-_Q804-Pad2_ AUX12-TGL 10K
R816 Net-_R815-Pad1_ Net-_C802-Pad2_ 27K
D805 Net-_C803-Pad2_ Net-_C802-Pad2_ 1N904
R814 Net-_C802-Pad1_ Net-_R814-Pad2_ 20K
R837 Net-_R814-Pad2_ AUX7-12V 36K
R827 AUX7-12V AUX11-TGL 1K
C802 Net-_C802-Pad1_ Net-_C802-Pad2_ 33n
R813 Net-_C802-Pad2_ AUX11-TGL 1k3
R218 AUX1-10V E15-MPS 510
R219 Net-_D207-Pad2_ E1-T1 240
R220 AUX1-10V Net-_D207-Pad2_ 1k2
D207 Net-_D207-Pad2_ Net-_D207-Pad1_ 1N904
R222 E15-MPS Net-_D207-Pad1_ 2k2
R825 AUX7-12V AUX12-TGL 1K
Q803 AUX12-TGL Int-7 0 BCY58-IX
D806 Net-_D806-Pad2_ Net-_D803-Pad2_ 1N904
D803 Net-_D803-Pad2_ Net-_C805-Pad1_ 1N904
R810 Net-_D807-Pad2_ Net-_D806-Pad2_ 1k5
R805 AUX7-12V Net-_Q800-Pad1_ 5k1
R806 Net-_Q800-Pad1_ Net-_C805-Pad1_ 10K
R811 AUX7-12V Net-_D807-Pad2_ 1k5
D807 Net-_D807-Pad2_ AUX2-IDL 1N904
R803 Net-_D802-Pad2_ 0 5k6
D801 Net-_C800-Pad1_ Net-_D801-Pad1_ 1N904
D800 Net-_C801-Pad2_ Net-_C800-Pad1_ 1N904
R800 Net-_C801-Pad2_ 0 9k1
C800 Net-_C800-Pad1_ AUX12-TGL 470n
R801 Net-_D801-Pad1_ 0 270K
R802 Net-_D801-Pad1_ 0 75K
R817 Net-_C801-Pad1_ Net-_Q802-Pad1_ 10K
D802 Net-_D802-Pad2_ Net-_C801-Pad1_ 1N904
C801 Net-_C801-Pad1_ Net-_C801-Pad2_ 33n
R330 Net-_D310-Pad1_ 0 2k4
R331 AUX7-12V Net-_D310-Pad1_ 15K
D310 AUX8-T2^ Net-_D310-Pad1_ 1N904
D307 AUX8-T2^ Net-_D307-Pad1_ 1N904
R334 0 Net-_D307-Pad1_ 4k8
R838 Net-_D307-Pad1_ Net-_R814-Pad2_ 510K
R808 AUX7-12V Int-3 910
R818 Net-_Q802-Pad1_ 0 10K
R335 Net-_D307-Pad1_ AUX7-12V 22K
R822 Net-_Q802-Pad2_ Net-_D310-Pad1_ 56K
R821 AUX7-12V Net-_Q802-Pad2_ 22K
Q802 Net-_Q802-Pad1_ Net-_Q802-Pad2_ Net-_Q802-Pad3_ S2066
R819 AUX7-12V Net-_Q802-Pad3_ 10K
R820 Net-_Q802-Pad2_ 0 68K
R332 AUX8-T2^ 0 1k5
Q304 AUX7-12V Net-_Q304-Pad2_ AUX8-T2^ S2672
D311 Net-_D311-Pad2_ E23-T2 1N904
R333 Net-_Q304-Pad2_ Net-_D311-Pad2_ 100
R306 AUX7-12V Net-_D311-Pad2_ 1k5
R807 Int-3 Net-_Q800-Pad2_ 15K
C805 Net-_C805-Pad1_ Net-_C805-Pad2_ 2.2n
R812 Net-_D804-Pad2_ Net-_C805-Pad1_ 4k3
Q801 Int-3 Net-_C805-Pad1_ 0 BCY58-IX
R809 Net-_C805-Pad1_ 0 6k8
R804 Net-_Q800-Pad2_ 0 6k8
Q800 Net-_Q800-Pad1_ Net-_Q800-Pad2_ 0 BCY58-IX
R835 Net-_Q800-Pad2_ Net-_C805-Pad2_ 300
D804 Net-_D804-Pad2_ Net-_C802-Pad1_ 1N904
R217 AUX10-SP Net-_C202-Pad1_ 2k4
Q201 AUX9-BP Net-_C202-Pad1_ 0 BCY59-IX
Q200 AUX10-SP Net-_D205-Pad1_ 0 BCY58-IX
C202 Net-_C202-Pad1_ Net-_C202-Pad2_ 1.0n
R216 AUX1-10V AUX10-SP 2K
R213 Net-_D205-Pad1_ 0 180K
R215 Net-_C202-Pad2_ Net-_D205-Pad1_ 300
D205 Net-_D203-Pad2_ Net-_D205-Pad1_ 1N904
C200 Net-_C200-Pad1_ AUX12-TGL 6.8n
R211 Net-_C201-Pad1_ 0 68K
D203 Net-_D203-Pad2_ Net-_C201-Pad1_ 1N904
R210 Net-_C200-Pad1_ 0 68K
R224 AUX1-10V AUX9-BP 1K
R214 AUX1-10V Net-_D203-Pad2_ 100K
R209 AUX1-10V Net-_C200-Pad1_ 130K
D204 Net-_D203-Pad2_ Net-_C200-Pad1_ 1N904
R212 AUX1-10V Net-_C201-Pad1_ 130K
C201 Net-_C201-Pad1_ AUX11-TGL 6.8n
D206 Net-_D203-Pad2_ E8-MPS DIODE.7V
Q904 Net-_C904-Pad1_ Net-_C905-Pad2_ 0 BCY58-IX
R923 Net-_C904-Pad1_ AUX7-12V 1k8
R925 Net-_D906-Pad1_ Net-_C905-Pad1_ 300
R916 Net-_D906-Pad1_ 0 180k
R924 Net-_C905-Pad2_ 0 180k
C905 Net-_C905-Pad1_ Net-_C905-Pad2_ 3.3n
C907 AUX16-EP Net-_C907-Pad2_ 100p
D913 AUX16-EP AUX2-IDL 1N904
D911 AUX2-IDL AUX3-AE9 1N904
R911 AUX7-12V AUX16-EP 2k2
R918 Net-_C904-Pad1_ AUX5-AE20 10K
D907 Net-_D907-Pad2_ Net-_C905-Pad2_ 1N904
R927 Net-_C903-Pad1_ AUX3-AE9 10K
R917 Net-_D906-Pad2_ AUX5-AE20 3K
D910 Net-_D910-Pad2_ Net-_D907-Pad2_ 1N904
D906 Net-_D906-Pad2_ Net-_D906-Pad1_ 1N904
R926 Net-_D910-Pad2_ AUX3-AE9 3K
C901 Net-_C901-Pad1_ Net-_C901-Pad2_ 2.2n
D912 Net-_D912-Pad2_ Net-_C901-Pad2_ 1N904
R910 Net-_C907-Pad2_ Net-_C901-Pad1_ 300
Q902 AUX16-EP Net-_C907-Pad2_ 0 BCY58-IX
R938 Net-_C901-Pad2_ 0 240K
R909 Net-_D912-Pad2_ AUX16-EP 18K
R913 Net-_C907-Pad2_ 0 180K
R937 Net-_D912-Pad2_ 0 47K
D903 Net-_C902-Pad2_ Net-_C907-Pad2_ 1N904
R906 Net-_D901-Pad1_ Net-_D909-Pad1_ 3K
R912 AUX7-12V Net-_C902-Pad2_ 56K
Q901 Net-_D909-Pad1_ Net-_C901-Pad2_ 0 BCY58-IX
D909 Net-_C902-Pad1_ Net-_D909-Pad1_ 1N904
R936 AUX7-12V Net-_D909-Pad1_ 10K
R919 AUX7-12V Net-_C902-Pad2_ 82K
C902 Net-_C902-Pad1_ Net-_C902-Pad2_ 100n
D904 Net-_C902-Pad2_ Net-_C903-Pad2_ 1N904
R920 AUX7-12V Net-_C903-Pad2_ 20K
C903 Net-_C903-Pad1_ Net-_C903-Pad2_ 47n
R922 Net-_C903-Pad1_ AUX7-12V 1k8
Q903 Net-_C903-Pad1_ Net-_D906-Pad1_ 0 BCY58-IX
R929 Net-_D901-Pad2_ 0 390
R932 AUX7-12V Net-_Q905-Pad3_ 14K
R901 AUX7-12V Net-_D901-Pad2_ 160
Q905 Int-A1 Net-_C900-Pad2_ Net-_Q905-Pad3_ S2066
D908 Int-A1 Net-_D908-Pad1_ 1N904
D901 Net-_D901-Pad2_ Net-_D901-Pad1_ 1N904
C900 AUX7-12V Net-_C900-Pad2_ 10uF
D902 Net-_C900-Pad2_ Net-_D901-Pad1_ 1N904
R931 AUX7-12V Net-_D908-Pad1_ 270
R933 AUX7-12V Net-_Q905-Pad3_ 160K
D900 Int-A2 Net-_D900-Pad1_ 1N904
R928 AUX7-12V Net-_D900-Pad1_ 270
Q900 Int-A2 Net-_C900-Pad2_ Net-_Q900-Pad3_ S2066
R904 AUX7-12V Net-_Q900-Pad3_ 160K
R903 AUX7-12V Net-_Q900-Pad3_ 14K
R161 Net-_Q109-Pad2_ Net-_D120-Pad1_ 150
R162 AUX7-12V Net-_D120-Pad1_ 680
D120 0 Net-_D120-Pad1_ PWR_REG_ZENER
Q109 AUX7-12V Net-_Q109-Pad2_ AUX1-10V BSX45
R921 AUX7-12V Net-_C904-Pad2_ 20K
R914 Net-_C903-Pad2_ 0 8k2
R930 AUX7-12V Net-_D908-Pad1_ 1K
R934 Net-_D908-Pad1_ 0 270
R902 AUX7-12V Net-_D900-Pad1_ 1K
R900 Net-_D900-Pad1_ 0 270
C906 AUX7-12V Net-_C906-Pad2_ 2.2u
R907 AUX7-12V Net-_C900-Pad2_ 100K
D905 Net-_C902-Pad2_ Net-_C904-Pad2_ 1N904
R915 Net-_C904-Pad2_ 0 8k2
C904 Net-_C904-Pad1_ Net-_C904-Pad2_ 47n
R908 AUX7-12V Net-_C906-Pad2_ 150K
R935 Net-_C902-Pad1_ Net-_C906-Pad2_ 15K
R111 AUX13-SV Net-_Q102-Pad2_ 22K
R135 AUX13-SV AUX1-10V 510
R108 AUX13-SV AUX1-10V 1K
R107 Net-_C101-Pad1_ AUX1-10V 36K
D101 Net-_C101-Pad1_ Net-_D101-Pad1_ 1N904
D107 Net-_C104-Pad2_ Net-_D106-Pad1_ 1N904
D106 Net-_C103-Pad2_ Net-_D106-Pad1_ 1N904
D110 Net-_D110-Pad2_ Net-_D106-Pad1_ 1N904
R134 Net-_Q103-Pad2_ Net-_D106-Pad1_ 1K
Q102 Net-_Q102-Pad1_ Net-_Q102-Pad2_ 0 BCY58-IX
R113 Net-_D103-Pad1_ Net-_Q102-Pad1_ 560
R116 AUX1-10V Net-_D103-Pad1_ 2K
C104 0 Net-_C104-Pad2_ 330n
D103 Net-_C104-Pad2_ Net-_D103-Pad1_ 1N904
R308 Net-_Q302-Pad2_ Net-_R307-Pad1_ 5k6
Q302 Net-_C300-Pad1_ Net-_Q302-Pad2_ Net-_D302-Pad1_ S2066
R325 Net-_D308-Pad1_ Net-_R307-Pad1_ 27K
R324 Net-_D308-Pad1_ Net-_R307-Pad1_ 4k7
R307 Net-_R307-Pad1_ 0 4k7
R105 0 Net-_D101-Pad1_ 180K
R110 Net-_Q102-Pad2_ 0 24K
Q101 AUX13-SV Net-_D101-Pad1_ 0 BCY58-X
D102 AUX13-SV Net-_C103-Pad2_ 1N904
D305 AUX8-T2^ Net-_D305-Pad1_ 1N904
R313 Net-_R309-Pad1_ Net-_D305-Pad1_ 1k1
R327 Net-_Q302-Pad2_ Net-_R309-Pad1_ 6k8
R309 Net-_R309-Pad1_ AUX7-12V 15K
Q352 Net-_C350-Pad1_ Net-_Q302-Pad2_ Net-_D352-Pad1_ S2066
R361 Net-_D352-Pad1_ AUX7-12V 180K
R329 Net-_R309-Pad1_ AUX7-12V 130K
R311 Net-_D302-Pad1_ AUX7-12V 220K
D308 AUX8-T2^ Net-_D308-Pad1_ 1N904
R120 AUX1-10V Net-_R117-Pad1_ 1k8
R117 Net-_R117-Pad1_ Net-_C104-Pad2_ 47K
R118 Net-_R117-Pad1_ Net-_C104-Pad2_ 240K
R119 Net-_R117-Pad1_ 0 16K
Q103 AUX1-10V Net-_Q103-Pad2_ AUX6-VE^ BCY58-X
R133 AUX1-10V Net-_D110-Pad2_ 5k6
R132 Net-_D110-Pad2_ 0 5k6
C101 Net-_C101-Pad1_ Net-_C101-Pad2_ 150n
R106 Net-_C101-Pad1_ AUX1-10V 560K
D100 Net-_C100-Pad1_ Net-_D100-Pad1_ 1N904
Q100 Net-_C101-Pad2_ Net-_D100-Pad1_ 0 BCY58-X
R104 Net-_C101-Pad2_ AUX1-10V 680
R103 Net-_C100-Pad1_ AUX1-10V 27K
R101 0 Net-_D100-Pad1_ 180K
Q300 AUX18-BP Net-_Q300-Pad2_ 0 BCY58-IX
D352 Net-_D352-Pad2_ Net-_D352-Pad1_ 1N904
R302 AUX18-BP AUX7-12V 2K
R367 Net-_D352-Pad2_ AUX7-12V 10K
D353 Net-_D352-Pad2_ Net-_C101-Pad2_ 1N904
R300 0 Net-_Q300-Pad2_ 10K
R301 AUX9-BP Net-_Q300-Pad2_ 20K
R351 AUX9-BP Net-_Q350-Pad2_ 20K
R352 AUX15-BP AUX7-12V 2K
Q350 AUX15-BP Net-_Q350-Pad2_ 0 BCY58-IX
R373 AUX11-TGL Net-_Q350-Pad2_ 20K
R100 Net-_C100-Pad2_ AUX10-SP 2K
D356 Net-_D352-Pad2_ AUX12-TGL 1N904
R366 Net-_D352-Pad2_ AUX7-12V 180K
R323 Net-_Q300-Pad2_ AUX12-TGL 20K
R350 0 Net-_Q350-Pad2_ 10K
C100 Net-_C100-Pad1_ Net-_C100-Pad2_ 100n
R102 Net-_C100-Pad1_ AUX1-10V 180K
R317 Net-_D302-Pad2_ AUX7-12V 120K
R147 Net-_R128-Pad2_ AUX1-10V 7k5
R128 Net-_C103-Pad2_ Net-_R128-Pad2_ 91K
R146 0 Net-_R128-Pad2_ 2k4
R129 Net-_C103-Pad2_ Net-_R128-Pad2_ 130K
R312 0 Net-_D301-Pad1_ 180K
D312 0 Net-_D301-Pad1_ 1N904
D301 Net-_C300-Pad1_ Net-_D301-Pad1_ 1N904
D354 0 Net-_C351-Pad1_ 1N904
Q353 AUX14-MP^ Net-_C351-Pad1_ 0 BCY58-IX
Q303 AUX17-MP^ Net-_D301-Pad1_ 0 BCY58-IX
R365 AUX14-MP^ AUX7-12V 3K
R127 Net-_D106-Pad1_ 0 510K
R360 Net-_D352-Pad1_ AUX7-12V 15K
C103 0 Net-_C103-Pad2_ 68n
R362 0 Net-_C351-Pad1_ 180K
D351 Net-_C350-Pad1_ Net-_C351-Pad1_ 1N904
C350 Net-_C350-Pad1_ Int-A2 680n
Q351 Int-A2 AUX15-BP Net-_Q351-Pad3_ S2066
R354 Net-_Q351-Pad3_ AUX7-12V 11K
R353 Net-_Q351-Pad3_ AUX7-12V 2k2
R363 AUX15-BP Net-_C351-Pad2_ 1K
C351 Net-_C351-Pad1_ Net-_C351-Pad2_ 2.2n
C300 Net-_C300-Pad1_ Int-A1 680n
R310 Net-_D302-Pad1_ AUX7-12V 15K
R315 AUX17-MP^ AUX7-12V 3K
R303 Net-_Q301-Pad3_ AUX7-12V 2k2
Q301 Int-A1 AUX18-BP Net-_Q301-Pad3_ S2066
D306 Net-_D302-Pad2_ AUX11-TGL 1N904
D303 Net-_D302-Pad2_ Net-_C101-Pad2_ 1N904
R316 Net-_D302-Pad2_ AUX7-12V 10K
D302 Net-_D302-Pad2_ Net-_D302-Pad1_ 1N904
R368 Net-_D304-Pad2_ Net-_D352-Pad2_ 5k6
R369 Net-_D304-Pad2_ Net-_D352-Pad2_ 22K
R318 Net-_D302-Pad2_ Net-_D304-Pad2_ 5k6
R320 0 Net-_D304-Pad2_ 2K
R319 Net-_D302-Pad2_ Net-_D304-Pad2_ 28K
D304 Net-_D304-Pad2_ AUX7-12V ENG_SPD_ZENER
C301 Net-_C301-Pad1_ AUX18-BP 1.0n
R304 Net-_Q301-Pad3_ AUX7-12V 12K
R326 Net-_C301-Pad1_ Net-_D301-Pad1_ 1K
R16 /Simulation/TEST4 0 4.2k
D1 E19-FPR Net-_D1-Pad2_ 1N904
R15 Net-_D1-Pad2_ /Simulation/TEST4 10k
R19 Net-_L19-Pad2_ AUX7-12V 62.3
R18 Net-_R18-Pad1_ 0 45
R4 Net-_L11-Pad2_ 0 4
VT1 E4-INJ4-8 Net-_L4-Pad1_ dc 0
VT2 E4-INJ4-8 Net-_R18-Pad1_ dc 0
L10 Net-_L10-Pad1_ Net-_L10-Pad2_ 680uH
L11 Net-_L10-Pad2_ Net-_L11-Pad2_ 680uH
L4 Net-_L4-Pad1_ Net-_L4-Pad2_ 680uH
L9 Net-_L4-Pad2_ Net-_L10-Pad1_ 680uH
R60 E5-INJ6-3 0 45
V3 TPS-ENRICH-EN 0 dc(0)
V4 THROTTLE-POS-PCENT 0 dc(0.04)
R6 Net-_L6-Pad2_ 0 2.7
L6 E5-INJ6-3 Net-_L6-Pad2_ 3.77mH
V2 TPS-VCC 0 dc 4.5
V1 AIR-TEMP-C 0 dc 22
V23 COOLANT-TEMP-C 0 dc 0
L19 E19-FPR Net-_L19-Pad2_ 45mH
XTH1 E1-T1 0 AIR-TEMP-C 0 airtemp
XTH2 E23-T2 0 COOLANT-TEMP-C 0 coolanttemp
L1 Net-_L1-Pad1_ Net-_L1-Pad2_ 3.77mH
R1 Net-_L1-Pad2_ 0 2.7
VINJCUR1 E3-INJ1-5 Net-_L1-Pad1_ dc 0
R5 Net-_L5-Pad2_ 0 2.7
L5 E3-INJ1-5 Net-_L5-Pad2_ 3.77mH
VINJCUR3 E3-INJ1-5 Net-_R10-Pad1_ dc 0
R10 Net-_R10-Pad1_ 0 45
V5 ENGINE_VAC 0 dc 9
V7 E18-START 0 dc(0)
V6 RHEOSTAT_POS 0 dc(11)
R2 Net-_L2-Pad2_ 0 2.7
R20 E6-INJ7-2 0 45
R7 Net-_L7-Pad2_ 0 2.7
L7 E6-INJ7-2 Net-_L7-Pad2_ 3.77mH
L2 E6-INJ7-2 Net-_L2-Pad2_ 3.77mH
R70 E6-INJ7-2 0 45
R3 Net-_L3-Pad2_ 0 2.7
R30 E5-INJ6-3 0 45
L3 E5-INJ6-3 Net-_L3-Pad2_ 3.77mH
XSW1 THROTTLE-POS-PCENT TPS-ENRICH-EN AUX2-IDL E2-TPS AUX3-AE9 AUX5-AE20 TPS-VCC 0 tps
V13 E13-PG 0 dc 5 pulse(5 0 4.5m 100u 100u 7.6m 18m)

V22 E22-PG 0 dc 5 pulse(0 5 0m 100u 100u 7.6m 18m)

V14 E14-PG 0 dc 5 pulse(0 5 3.1m 100u 100u 10.4m 18m)

XMPS1 AUX9-BP E15-MPS E8-MPS E10-MPS ENGINE_VAC 0 mps
R8 E18-START 0 32
V21 E21-PG 0 dc 5 pulse(0 5 9m 100u 100u 7.6m 18m)

V24 E24-12V 0 dc 13.5
V16 AUX7-12V 0 dc 13.5
.model BSX45 NPN(Is=66.19f Xti=3 Eg=1.11 Vaf=100 Bf=600.9 Ise=93.12f Ne=1.31 Ikf=.1347 Xtb=1.2 Br=889.8 Isc=3.42n Nc=1.74 Ikr=12.98 Rc=.5886 Cjc=60.73p Mjc=.3333 Vjc=.5 Fc=.5 Cje=94.85p Mje=.3333 Vje=.5 Tr=10n Tf=1.353n Itf=2.957 Xtf=145.5 Vtf=10)
.model BCY58-IX NPN(Is=64.04f Xti=3 Eg=1.11 Vaf=62.37 Bf=473.2 Ise=549.7f Ne=1.721 Ikf=.1237 Nkf=.6057 Xtb=1.5 Br=1 Isc=22.53n Nc=3.624 Ikr=10.72 Rc=1.261 Cjc=11.15p Mjc=.3333 Vjc=.5 Fc=.5 Cje=16.78p Mje=.3333 Vje=.5 Tr=622.7n Tf=423.4p Itf=3.503 Xtf=107 Vtf=10 Ic=200m)
.model BCY58-X NPN(Is=64.04f Xti=3 Eg=1.11 Vaf=35.7 Bf=676 Ise=444.3f Ne=1.771 Ikf=.1013 Nkf=.6259 Xtb=1.5 Br=1 Isc=38.48n Nc=4.097 Ikr=5.942 Rc=1.19 Cjc=11.15p Mjc=.3333
.model BCY59-IX NPN(Is=64.04f Xti=3 Eg=1.11 Vaf=62.37 Bf=473.2 Ise=549.7f Ne=1.721 Ikf=.1237 Nkf=.6057 Xtb=1.5 Br=1 Isc=22.53n Nc=3.624 Ikr=10.72 Rc=1.261 Cjc=11.15p Mjc=.3333 Vjc=.5 Fc=.5 Cje=16.78p Mje=.3333 Vje=.5 Tr=622.7n Tf=423.4p Itf=3.503 Xtf=107 Vtf=10 Ic=200m)
.model S2672 NPN(Is=64.04f Xti=3 Eg=1.11 Vaf=35.7 Bf=676 Ise=444.3f Ne=1.771 Ikf=.1013 Nkf=.6259 Xtb=1.5 Br=1 Isc=38.48n Nc=4.097 Ikr=5.942 Rc=1.19 Cjc=11.15p Mjc=.3333
.model AUY21 PNP(Bf=75 Is=36u Re=0.04456 Vaf=48 Ise=480n Tf=530n Tr=10u)
.model S2066 PNP(Is=336.7f Xti=3 Eg=1.11 Vaf=55.46 Bf=154.4 Ise=412.1f Ne=1.429 Ikf=.2994 Nkf=.7028 Xtb=1.5 Br=3.99 Isc=1.03n Nc=1.958 Ikr=9.726 Rc=1.833 Cjc=11p Mjc=.2223 Vjc=.5 Fc=.5 Cje=33p Mje=.3333 Vje=.5 Tr=10n Tf=847.7p Itf=2.198 Xtf=23.26 Vtf=10 Ic=100m)
.model PWR_REG_ZENER D(BV=10.12)
.model PMP_CNTL_ZENER D(BV=801.9m)
.model ENG_SPD_ZENER D(BV=12.02)
.model ZENER_11.4 D(BV=11.4)
.model ZENER_0.1 D(BV=100m)
.model 1N904 D
.model DIODE.5V D
.model DIODE.6V D
.model DIODE.67V D
.model DIODE.7V D
.model ZENER_5.1 D(BV=5.1)
.tran 8us 200ms 0
.options CHGTOL=1e-25
.control
run
.endc
.end
